/*
  Created by Fabrizio Di Vittorio (fdivitto2013@gmail.com) - <http://www.fabgl.com>
  Copyright (c) 2019-2022 Fabrizio Di Vittorio.
  All rights reserved.


* Please contact fdivitto2013@gmail.com if you need a commercial license.


* This library and related software is available under GPL v3.

  FabGL is free software: you can redistribute it and/or modify
  it under the terms of the GNU General Public License as published by
  the Free Software Foundation, either version 3 of the License, or
  (at your option) any later version.

  FabGL is distributed in the hope that it will be useful,
  but WITHOUT ANY WARRANTY; without even the implied warranty of
  MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
  GNU General Public License for more details.

  You should have received a copy of the GNU General Public License
  along with FabGL.  If not, see <http://www.gnu.org/licenses/>.
 */


#include <memory>

#include "fabgl.h"
#include "fabutils.h"


#include "mconf.h"


using std::unique_ptr;
using fabgl::imin;




////////////////////////////////////////////////////////////////////////////////////////////////////////////
////////////////////////////////////////////////////////////////////////////////////////////////////////////
// MachineConf


// Long enough for the longest tag plus room to grow. Tags longer than this are silently
// truncated and then match nothing, which is invisible from the outside: "enabledebug" is 11
// characters and was being cut to "enable", so the option simply did nothing.
#define MAXTAGLENGTH    16
#define MAXVALUELENGTH 256


MachineConf::MachineConf()
  : m_itemsList(nullptr)
{
}


MachineConf::~MachineConf()
{
  cleanUp();
}


void MachineConf::cleanUp()
{
  while (deleteItem(0))
    ;
}


bool MachineConf::deleteItem(int index)
{
  MachineConfItem * item = m_itemsList;
  MachineConfItem * prev = nullptr;
  while (item && --index > -1) {
    prev = item;
    item = item->next;
  }
  if (item) {
    if (prev)
      prev->next = item->next;
    else
      m_itemsList = item->next;
    delete item;
  }
  return item != nullptr;
}


MachineConfItem * MachineConf::getItem(int index)
{
  auto item = m_itemsList;
  while (item && --index > -1)
    item = item->next;
  return item;
}


void MachineConf::addItem(MachineConfItem * item)
{
  if (item->isValid()) {
    if (m_itemsList) {
      auto prev = m_itemsList;
      while (prev->next)
        prev = prev->next;
      prev->next = item;
    } else
      m_itemsList = item;
  } else
    delete item;
}


// insertingPoint = -1, append
// insertingPoint = 0, insert before first
// insertingPoint > 0, insert before insertingPoint
void MachineConf::insertItem(int insertingPoint, MachineConfItem * item)
{
  if (insertingPoint == 0) {
    item->next = m_itemsList;
    m_itemsList = item;
  } else if (insertingPoint < 0) {
    addItem(item);
  } else {
    auto prev = getItem(insertingPoint - 1);
    item->next = prev->next;
    prev->next = item;
  }
}


void MachineConf::loadFromFile(FILE * file)
{
  cleanUp();
  auto item = new MachineConfItem;
  char * value = (char*) SOC_EXTRAM_DATA_LOW; // use PSRAM as buffer
  char * tag   = (char*) SOC_EXTRAM_DATA_LOW + MAXVALUELENGTH + 1;
  int ipos;
  char c = fgetc(file);
  while (!feof(file)) {
    while (!feof(file) && (isspace(c) || iscntrl(c))) {
      if (c == 0x0a) {
        // new line
        addItem(item);
        item = new MachineConfItem;
      }
      c = fgetc(file);
    }
    // get tag
    ipos = 0;
    while (!feof(file) && !isspace(c)) {
      if (ipos < MAXTAGLENGTH)
        tag[ipos++] = c;
      c = fgetc(file);
    }
    tag[ipos] = 0;
    // bypass spaces
    while (!feof(file) && isspace(c))
      c = fgetc(file);
    // get tag value
    ipos = 0;
    bool quote = false;
    while (!feof(file) && (quote || !isspace(c))) {
      if (c == '"')
        quote = !quote;
      else if (ipos < MAXVALUELENGTH)
        value[ipos++] = c;
      c = fgetc(file);
    }
    value[ipos] = 0;
    // assign tag
    if (strcmp("desc", tag) == 0)
      item->setDesc(value);
    else if (strcmp("dska", tag) == 0 || strcmp("fd0", tag) == 0)
      item->setDisk(0, value);
    else if (strcmp("dskb", tag) == 0 || strcmp("fd1", tag) == 0)
      item->setDisk(1, value);
    else if (strcmp("dskc", tag) == 0 || strcmp("hd0", tag) == 0)
      item->setDisk(2, value);
    else if (strcmp("dskd", tag) == 0 || strcmp("hd1", tag) == 0)
      item->setDisk(3, value);
    else if (strcmp("chs0", tag) == 0)
      item->setCHS(2, value);
    else if (strcmp("chs1", tag) == 0)
      item->setCHS(3, value);
    else if (strcmp("boot", tag) == 0)
      item->setBootDrive(value);
    else if (strcmp("ram", tag) == 0)
      item->setRamSize(value);
    else if (strcmp("enabledebug", tag) == 0)
      item->setDebugConsole(value);
    else if (strcmp("usbserial", tag) == 0)
      item->setUsbSerial(value);
    else if (strcmp("hwserial", tag) == 0)
      item->setHwSerial(value);
    else if (strcmp("video", tag) == 0)
      item->setVideoAdapter(value);
    else if (strcmp("egarom", tag) == 0)
      item->setEgaRom(value);
    else if (strcmp("tandysound", tag) == 0)
      item->setTandySound(value);
    else if (strcmp("tandydac", tag) == 0)
      item->setTandyDAC(value);
    else if (strcmp("composite", tag) == 0)
      item->setComposite(value);
    else if (strcmp("adlib", tag) == 0)
      item->setAdLib(value);
    else if (strcmp("hwdisk", tag) == 0)
      item->setHwDisk(value);
    else if (strcmp("clock", tag) == 0)
      item->setClock(value);
    else if (tag[0])
      // Say so rather than ignoring it. A mistyped or over-long tag otherwise looks exactly
      // like a feature that does not work.
      printf("mconfs.txt: ignoring unknown tag \"%s\"\n", tag);
  }
  addItem(item);
}


void MachineConf::saveToFile(FILE * file)
{
  for (auto item = m_itemsList; item; item = item->next) {
    fputs("desc \"", file);
    fputs(item->desc, file);
    fputs("\" ", file);
    for (int d = 0; d < DISKCOUNT; ++d)
      if (item->disk[d] && strlen(item->disk[d]) > 0) {
        fputs(MachineConfItem::driveIndexToStr(d), file);
        fputs(" \"", file);
        fputs(item->disk[d], file);
        fputs("\" ", file);
      }
    for (int hd = 2; hd < 4; ++hd)
      if (item->cylinders[hd] > 0 && item->heads[hd] > 0 && item->sectors[hd] > 0)
        fprintf(file, "chs%d %hu,%hu,%hu ", hd - 2, item->cylinders[hd], item->heads[hd], item->sectors[hd]);
    if (item->bootDrive > 0)
      fprintf(file, "boot %s ", MachineConfItem::driveIndexToStr(item->bootDrive));
    if (item->ramSizeKB != 640)
      fprintf(file, "ram %hu ", item->ramSizeKB);
    // only written when on, so machines that never asked for it keep the file they had
    if (item->debugConsole)
      fputs("enabledebug 1 ", file);
    // only written when it was asked for, so files that never mentioned it are left as they were
    if (item->usbSerialSet && item->usbSerial != 0)
      fprintf(file, "usbserial %s ", item->usbSerial == 2 ? "com2" : "com1");
    else if (item->usbSerialSet)
      fputs("usbserial off ", file);
    if (item->hwSerial != 0)
      fprintf(file, "hwserial %s ", item->hwSerial == 2 ? "com2" : "com1");
    if (item->videoAdapter == 1) {
      fputs("video ega ", file);
      if (item->egaRom && item->egaRom[0]) {
        fputs("egarom \"", file);
        fputs(item->egaRom, file);
        fputs("\" ", file);
      }
    } else if (item->videoAdapter == 2) {
      fputs("video tandy ", file);
    }
    // only written when on, like enabledebug; the Tandy video has the chip regardless
    if (item->tandySound && item->videoAdapter != 2)
      fputs("tandysound 1 ", file);
    if (item->tandyDAC)
      fputs("tandydac 1 ", file);
    if (item->composite)
      fputs("composite 1 ", file);
    if (item->adlib)
      fputs("adlib 1 ", file);
    if (item->hwDisk)
      fputs("hwdisk 1 ", file);
    // only written when not the AT clock, the default
    if (item->clock == 1)
      fputs("clock mm58174 ", file);
    else if (item->clock == 2)
      fputs("clock none ", file);
    fputs("\r\n", file);
  }
}



////////////////////////////////////////////////////////////////////////////////////////////////////////////
////////////////////////////////////////////////////////////////////////////////////////////////////////////
// helpers


void loadMachineConfiguration(MachineConf * mconf)
{
  FileBrowser fb(SD_MOUNT_PATH);

  // A fresh SD card starts with an empty list: machines come from a repository (F6 on the
  // selection screen) or the editor. There used to be a built-in list of fabglib.org images here.
  if (!fb.exists(MACHINE_CONF_FILENAME, false)) {
    auto confFile = fb.openFile(MACHINE_CONF_FILENAME, "wb");
    fclose(confFile);
  }

  // load
  auto confFile = fb.openFile(MACHINE_CONF_FILENAME, "rb");
  mconf->loadFromFile(confFile);
  fclose(confFile);
}


void saveMachineConfiguration(MachineConf * mconf)
{
  auto confFile = FileBrowser(SD_MOUNT_PATH).openFile(MACHINE_CONF_FILENAME, "wb");
  mconf->saveToFile(confFile);
  fclose(confFile);
}


// Create FAT formatted floppy image
// diskType:
//   0 = 320
//   1 = 360
//   2 = 720
//   3 = 1200
//   4 = 1440
//   5 = 2880
// directory: absolute path (includes mounting point, ie "/SD/..."
bool createFATFloppyImage(TextUI * ui, int diskType, char const * directory, char const * filename)
{
  // boot sector for: 320K, 360K, 720K, 1440K, 2880K
  static const uint8_t BOOTSECTOR_WIN[512] = {
    0xeb, 0x3c, 0x90, 0x4d, 0x53, 0x57, 0x49, 0x4e, 0x34, 0x2e, 0x31, 0x00, 0x02, 0x01, 0x01, 0x00, 0x02, 0xe0, 0x00, 0x40, 0x0b, 0xf0, 0x09, 0x00,
    0x12, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x29, 0x00, 0x00, 0x00, 0x00, 0x20, 0x20, 0x20, 0x20, 0x20,
    0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x46, 0x41, 0x54, 0x31, 0x32, 0x20, 0x20, 0x20, 0x33, 0xc9, 0x8e, 0xd1, 0xbc, 0xfc, 0x7b, 0x16, 0x07, 0xbd,
    0x78, 0x00, 0xc5, 0x76, 0x00, 0x1e, 0x56, 0x16, 0x55, 0xbf, 0x22, 0x05, 0x89, 0x7e, 0x00, 0x89, 0x4e, 0x02, 0xb1, 0x0b, 0xfc, 0xf3, 0xa4, 0x06,
    0x1f, 0xbd, 0x00, 0x7c, 0xc6, 0x45, 0xfe, 0x0f, 0x38, 0x4e, 0x24, 0x7d, 0x20, 0x8b, 0xc1, 0x99, 0xe8, 0x7e, 0x01, 0x83, 0xeb, 0x3a, 0x66, 0xa1,
    0x1c, 0x7c, 0x66, 0x3b, 0x07, 0x8a, 0x57, 0xfc, 0x75, 0x06, 0x80, 0xca, 0x02, 0x88, 0x56, 0x02, 0x80, 0xc3, 0x10, 0x73, 0xed, 0x33, 0xc9, 0xfe,
    0x06, 0xd8, 0x7d, 0x8a, 0x46, 0x10, 0x98, 0xf7, 0x66, 0x16, 0x03, 0x46, 0x1c, 0x13, 0x56, 0x1e, 0x03, 0x46, 0x0e, 0x13, 0xd1, 0x8b, 0x76, 0x11,
    0x60, 0x89, 0x46, 0xfc, 0x89, 0x56, 0xfe, 0xb8, 0x20, 0x00, 0xf7, 0xe6, 0x8b, 0x5e, 0x0b, 0x03, 0xc3, 0x48, 0xf7, 0xf3, 0x01, 0x46, 0xfc, 0x11,
    0x4e, 0xfe, 0x61, 0xbf, 0x00, 0x07, 0xe8, 0x28, 0x01, 0x72, 0x3e, 0x38, 0x2d, 0x74, 0x17, 0x60, 0xb1, 0x0b, 0xbe, 0xd8, 0x7d, 0xf3, 0xa6, 0x61,
    0x74, 0x3d, 0x4e, 0x74, 0x09, 0x83, 0xc7, 0x20, 0x3b, 0xfb, 0x72, 0xe7, 0xeb, 0xdd, 0xfe, 0x0e, 0xd8, 0x7d, 0x7b, 0xa7, 0xbe, 0x7f, 0x7d, 0xac,
    0x98, 0x03, 0xf0, 0xac, 0x98, 0x40, 0x74, 0x0c, 0x48, 0x74, 0x13, 0xb4, 0x0e, 0xbb, 0x07, 0x00, 0xcd, 0x10, 0xeb, 0xef, 0xbe, 0x82, 0x7d, 0xeb,
    0xe6, 0xbe, 0x80, 0x7d, 0xeb, 0xe1, 0xcd, 0x16, 0x5e, 0x1f, 0x66, 0x8f, 0x04, 0xcd, 0x19, 0xbe, 0x81, 0x7d, 0x8b, 0x7d, 0x1a, 0x8d, 0x45, 0xfe,
    0x8a, 0x4e, 0x0d, 0xf7, 0xe1, 0x03, 0x46, 0xfc, 0x13, 0x56, 0xfe, 0xb1, 0x04, 0xe8, 0xc2, 0x00, 0x72, 0xd7, 0xea, 0x00, 0x02, 0x70, 0x00, 0x52,
    0x50, 0x06, 0x53, 0x6a, 0x01, 0x6a, 0x10, 0x91, 0x8b, 0x46, 0x18, 0xa2, 0x26, 0x05, 0x96, 0x92, 0x33, 0xd2, 0xf7, 0xf6, 0x91, 0xf7, 0xf6, 0x42,
    0x87, 0xca, 0xf7, 0x76, 0x1a, 0x8a, 0xf2, 0x8a, 0xe8, 0xc0, 0xcc, 0x02, 0x0a, 0xcc, 0xb8, 0x01, 0x02, 0x80, 0x7e, 0x02, 0x0e, 0x75, 0x04, 0xb4,
    0x42, 0x8b, 0xf4, 0x8a, 0x56, 0x24, 0xcd, 0x13, 0x61, 0x61, 0x72, 0x0a, 0x40, 0x75, 0x01, 0x42, 0x03, 0x5e, 0x0b, 0x49, 0x75, 0x77, 0xc3, 0x03,
    0x18, 0x01, 0x27, 0x0d, 0x0a, 0x49, 0x6e, 0x76, 0x61, 0x6c, 0x69, 0x64, 0x20, 0x73, 0x79, 0x73, 0x74, 0x65, 0x6d, 0x20, 0x64, 0x69, 0x73, 0x6b,
    0xff, 0x0d, 0x0a, 0x44, 0x69, 0x73, 0x6b, 0x20, 0x49, 0x2f, 0x4f, 0x20, 0x65, 0x72, 0x72, 0x6f, 0x72, 0xff, 0x0d, 0x0a, 0x52, 0x65, 0x70, 0x6c,
    0x61, 0x63, 0x65, 0x20, 0x74, 0x68, 0x65, 0x20, 0x64, 0x69, 0x73, 0x6b, 0x2c, 0x20, 0x61, 0x6e, 0x64, 0x20, 0x74, 0x68, 0x65, 0x6e, 0x20, 0x70,
    0x72, 0x65, 0x73, 0x73, 0x20, 0x61, 0x6e, 0x79, 0x20, 0x6b, 0x65, 0x79, 0x0d, 0x0a, 0x00, 0x00, 0x49, 0x4f, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
    0x53, 0x59, 0x53, 0x4d, 0x53, 0x44, 0x4f, 0x53, 0x20, 0x20, 0x20, 0x53, 0x59, 0x53, 0x7f, 0x01, 0x00, 0x41, 0xbb, 0x00, 0x07, 0x60, 0x66, 0x6a,
    0x00, 0xe9, 0x3b, 0xff, 0x00, 0x00, 0x55, 0xaa };

  // boot sector for: 1200K
  static const uint8_t BOOTSECTOR_MSDOS5[512] = {
    0xeb, 0x3c, 0x90, 0x4d, 0x53, 0x44, 0x4f, 0x53, 0x35, 0x2e, 0x30, 0x00, 0x02, 0x01, 0x01, 0x00, 0x02, 0xe0, 0x00, 0x60, 0x09, 0xf9, 0x08, 0x00,
    0x0f, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x29, 0xd1, 0x40, 0x38, 0xda, 0x20, 0x20, 0x20, 0x20, 0x20,
    0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x46, 0x41, 0x54, 0x31, 0x32, 0x20, 0x20, 0x20, 0xfa, 0x33, 0xc0, 0x8e, 0xd0, 0xbc, 0x00, 0x7c, 0x16, 0x07,
    0xbb, 0x78, 0x00, 0x36, 0xc5, 0x37, 0x1e, 0x56, 0x16, 0x53, 0xbf, 0x3e, 0x7c, 0xb9, 0x0b, 0x00, 0xfc, 0xf3, 0xa4, 0x06, 0x1f, 0xc6, 0x45, 0xfe,
    0x0f, 0x8b, 0x0e, 0x18, 0x7c, 0x88, 0x4d, 0xf9, 0x89, 0x47, 0x02, 0xc7, 0x07, 0x3e, 0x7c, 0xfb, 0xcd, 0x13, 0x72, 0x79, 0x33, 0xc0, 0x39, 0x06,
    0x13, 0x7c, 0x74, 0x08, 0x8b, 0x0e, 0x13, 0x7c, 0x89, 0x0e, 0x20, 0x7c, 0xa0, 0x10, 0x7c, 0xf7, 0x26, 0x16, 0x7c, 0x03, 0x06, 0x1c, 0x7c, 0x13,
    0x16, 0x1e, 0x7c, 0x03, 0x06, 0x0e, 0x7c, 0x83, 0xd2, 0x00, 0xa3, 0x50, 0x7c, 0x89, 0x16, 0x52, 0x7c, 0xa3, 0x49, 0x7c, 0x89, 0x16, 0x4b, 0x7c,
    0xb8, 0x20, 0x00, 0xf7, 0x26, 0x11, 0x7c, 0x8b, 0x1e, 0x0b, 0x7c, 0x03, 0xc3, 0x48, 0xf7, 0xf3, 0x01, 0x06, 0x49, 0x7c, 0x83, 0x16, 0x4b, 0x7c,
    0x00, 0xbb, 0x00, 0x05, 0x8b, 0x16, 0x52, 0x7c, 0xa1, 0x50, 0x7c, 0xe8, 0x92, 0x00, 0x72, 0x1d, 0xb0, 0x01, 0xe8, 0xac, 0x00, 0x72, 0x16, 0x8b,
    0xfb, 0xb9, 0x0b, 0x00, 0xbe, 0xe6, 0x7d, 0xf3, 0xa6, 0x75, 0x0a, 0x8d, 0x7f, 0x20, 0xb9, 0x0b, 0x00, 0xf3, 0xa6, 0x74, 0x18, 0xbe, 0x9e, 0x7d,
    0xe8, 0x5f, 0x00, 0x33, 0xc0, 0xcd, 0x16, 0x5e, 0x1f, 0x8f, 0x04, 0x8f, 0x44, 0x02, 0xcd, 0x19, 0x58, 0x58, 0x58, 0xeb, 0xe8, 0x8b, 0x47, 0x1a,
    0x48, 0x48, 0x8a, 0x1e, 0x0d, 0x7c, 0x32, 0xff, 0xf7, 0xe3, 0x03, 0x06, 0x49, 0x7c, 0x13, 0x16, 0x4b, 0x7c, 0xbb, 0x00, 0x07, 0xb9, 0x03, 0x00,
    0x50, 0x52, 0x51, 0xe8, 0x3a, 0x00, 0x72, 0xd8, 0xb0, 0x01, 0xe8, 0x54, 0x00, 0x59, 0x5a, 0x58, 0x72, 0xbb, 0x05, 0x01, 0x00, 0x83, 0xd2, 0x00,
    0x03, 0x1e, 0x0b, 0x7c, 0xe2, 0xe2, 0x8a, 0x2e, 0x15, 0x7c, 0x8a, 0x16, 0x24, 0x7c, 0x8b, 0x1e, 0x49, 0x7c, 0xa1, 0x4b, 0x7c, 0xea, 0x00, 0x00,
    0x70, 0x00, 0xac, 0x0a, 0xc0, 0x74, 0x29, 0xb4, 0x0e, 0xbb, 0x07, 0x00, 0xcd, 0x10, 0xeb, 0xf2, 0x3b, 0x16, 0x18, 0x7c, 0x73, 0x19, 0xf7, 0x36,
    0x18, 0x7c, 0xfe, 0xc2, 0x88, 0x16, 0x4f, 0x7c, 0x33, 0xd2, 0xf7, 0x36, 0x1a, 0x7c, 0x88, 0x16, 0x25, 0x7c, 0xa3, 0x4d, 0x7c, 0xf8, 0xc3, 0xf9,
    0xc3, 0xb4, 0x02, 0x8b, 0x16, 0x4d, 0x7c, 0xb1, 0x06, 0xd2, 0xe6, 0x0a, 0x36, 0x4f, 0x7c, 0x8b, 0xca, 0x86, 0xe9, 0x8a, 0x16, 0x24, 0x7c, 0x8a,
    0x36, 0x25, 0x7c, 0xcd, 0x13, 0xc3, 0x0d, 0x0a, 0x4e, 0x6f, 0x6e, 0x2d, 0x53, 0x79, 0x73, 0x74, 0x65, 0x6d, 0x20, 0x64, 0x69, 0x73, 0x6b, 0x20,
    0x6f, 0x72, 0x20, 0x64, 0x69, 0x73, 0x6b, 0x20, 0x65, 0x72, 0x72, 0x6f, 0x72, 0x0d, 0x0a, 0x52, 0x65, 0x70, 0x6c, 0x61, 0x63, 0x65, 0x20, 0x61,
    0x6e, 0x64, 0x20, 0x70, 0x72, 0x65, 0x73, 0x73, 0x20, 0x61, 0x6e, 0x79, 0x20, 0x6b, 0x65, 0x79, 0x20, 0x77, 0x68, 0x65, 0x6e, 0x20, 0x72, 0x65,
    0x61, 0x64, 0x79, 0x0d, 0x0a, 0x00, 0x49, 0x4f, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x53, 0x59, 0x53, 0x4d, 0x53, 0x44, 0x4f, 0x53, 0x20, 0x20,
    0x20, 0x53, 0x59, 0x53, 0x00, 0x00, 0x55, 0xaa };

  static const uint8_t * BOOTSECTOR[6] = {
    BOOTSECTOR_WIN,     // 320K
    BOOTSECTOR_WIN,     // 360K
    BOOTSECTOR_WIN,     // 720K
    BOOTSECTOR_MSDOS5,  // 1200K
    BOOTSECTOR_WIN,     // 1440K
    BOOTSECTOR_WIN,     // 2880K
  };

  // offset 0x0c (16 bytes):
  static const uint8_t GEOM[6][16]  = {
    { 0x02, 0x02, 0x01, 0x00, 0x02, 0x70, 0x00, 0x80, 0x02, 0xFF, 0x01, 0x00, 0x08, 0x00, 0x02, 0x00 },  // 320K
    { 0x02, 0x02, 0x01, 0x00, 0x02, 0x70, 0x00, 0xD0, 0x02, 0xFD, 0x02, 0x00, 0x09, 0x00, 0x02, 0x00 },  // 360K
    { 0x02, 0x02, 0x01, 0x00, 0x02, 0x70, 0x00, 0xA0, 0x05, 0xF9, 0x03, 0x00, 0x09, 0x00, 0x02, 0x00 },  // 720K
    { 0x02, 0x01, 0x01, 0x00, 0x02, 0xE0, 0x00, 0x60, 0x09, 0xF9, 0x08, 0x00, 0x0F, 0x00, 0x02, 0x00 },  // 1200K
    { 0x02, 0x01, 0x01, 0x00, 0x02, 0xE0, 0x00, 0x40, 0x0B, 0xF0, 0x09, 0x00, 0x12, 0x00, 0x02, 0x00 },  // 1440K
    { 0x02, 0x02, 0x01, 0x00, 0x02, 0xF0, 0x00, 0x80, 0x16, 0xF0, 0x09, 0x00, 0x24, 0x00, 0x02, 0x00 },  // 2880K
  };

  // sizes in bytes
  static const int SIZES[6] = {
    512 *  8 * 40 * 2, // 327680 (320K)
    512 *  9 * 40 * 2, // 368640 (360K)
    512 *  9 * 80 * 2, // 737280 (720K)
    512 * 15 * 80 * 2, // 1228800 (1200K)
    512 * 18 * 80 * 2, // 1474560 (1440K)
    512 * 36 * 80 * 2, // 2949120 (2880K)
  };

  // FAT
  static const struct {
    uint8_t id;
    uint8_t fat1size;  // in 512 blocks
    uint8_t fat2size;  // in 512 blocks
  } FAT[6] = {
    { 0xff, 1,  8 },   // 320K
    { 0xfd, 2,  9 },   // 360K
    { 0xf9, 3, 10 },   // 720K
    { 0xf9, 8, 22 },   // 1200K
    { 0xf0, 9, 23 },   // 1440K
    { 0xf0, 9, 24 },   // 2880K
  };

  auto file = FileBrowser(directory).openFile(filename, "wb");

  if (file) {

    auto sectbuf = (uint8_t*) SOC_EXTRAM_DATA_LOW; // use PSRAM as buffer

    // initial fill with all 0xf6 up to entire size
    memset(sectbuf, 0xf6, 512);
    fseek(file, 0, SEEK_SET);

    ui->progress("Create Disk Image", true, [&](TextUI::Progress & p) {
      int prevPerc = -1;
      for (int i = 0; i < SIZES[diskType]; i += 512) {
        fwrite(sectbuf, 1, 512, file);
        // redraw only when the bar moves, a 2.88M image is 5760 sectors
        int perc = (int)((double)i / SIZES[diskType] * 100);
        if (perc != prevPerc) {
          prevPerc = perc;
          if (!p.update(perc, "Formatting %s  %d / %d KB", filename, i >> 10, SIZES[diskType] >> 10))
            break;
        }
      }
    });

    // offset 0x00 (512 bytes) : write boot sector
    fseek(file, 0, SEEK_SET);
    fwrite(BOOTSECTOR[diskType], 1, 512, file);

    // offset 0x0c (16 bytes) : disk geometry
    fseek(file, 0x0c, SEEK_SET);
    fwrite(GEOM[diskType], 1, 16, file);

    // offset 0x27 (4 bytes) : Volume Serial Number
    const uint32_t volSN = rand();
    fseek(file, 0x27, SEEK_SET);
    fwrite(&volSN, 1, 4, file);

    // FAT
    memset(sectbuf, 0x00, 512);
    fseek(file, 0x200, SEEK_SET);
    for (int i = 0; i < (FAT[diskType].fat1size + FAT[diskType].fat2size); ++i)
      fwrite(sectbuf, 1, 512, file);
    sectbuf[0] = FAT[diskType].id;
    sectbuf[1] = 0xff;
    sectbuf[2] = 0xff;
    fseek(file, 0x200, SEEK_SET);
    fwrite(sectbuf, 1, 3, file);
    fseek(file, 0x200 + FAT[diskType].fat1size * 512, SEEK_SET);
    fwrite(sectbuf, 1, 3, file);

    fclose(file);
  }

  return file != nullptr;
}
